# Keil uVision project RTOS_V1.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: RTOS_V1
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: E:\RTOS_V1\include
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group include
    ../include/OS/: os.h Process.h Queues.h
  group OS
    ../OS/: process.c Queues.c scheduler.c os.c
  group processor_specific
    ../processor_Specific/: synchronization_asm.s context_switch.s
  group User Functions
    ../User Functions/: user_func.c main.c
software components: CMSIS:CORE 5.1.2, Device:Startup 1.0.1
